Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2025-07-24T14:57:57+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact Duo_INT-EN:EMCK-D45-8.1, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact Duo_INT-EN:EMCK-D45-8.1:43794
In: Level 1
Type - Material: Color RGB 040-040-040, Color RAL 1003, Color RGB 200-200-200, Color RGB 181-166-066, Color RGB 250-000-000, Color RGB 115-115-115, Color RGB 255-255-255, Color RGB 055-055-055
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 728 mm; Drain Diameter: 50 mm; Height: 1396 mm; Overflow Diameter: 25.4 mm; Pressure Diameter: 25.4 mm; Refill Diameter: 12.7 mm; Use Nominal Diameter: yes; Width: 575 mm
Type - Electrical - Loads - Power: 1500 W
Type - Electrical Engineering - Voltage: 230 V
Type - Identity Data - Article Description: SpiroExpand MultiControl Kompact Duo; Article Type: EMCK-D45-8.1; Base Family Version: 25.08; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: SpiroExpand MultiControl Kompact Duo; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 25.08; GLN: 8717811000007; GTIN: 8717811052198; Manufacturer: Spirotech; Manufacturer Art. No.: EMCK-D45-8.1; Manufacturer URL: https://www.spirotech.com/products/spiroexpand-pressurization/spiroexpand-multicontrol-kompakt-duo-192; MEPcontent Class: EXPANSIONVESSEL; Model: EMCK-D45-8.1; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: SpiroExpand; Revit Version: 2023; Type Name: EMCK-D45-8.1; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Gray: Color RGB 200-200-200; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Mechanical - Volume: 0.045 m3
Type - Other - Category: Mechanical Equipment; D125: no; D200: no; D300: no; D45: yes; D500: no; D75: no; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact Duo_INT-EN
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EMCK-D45-8.1
Pset_EnvironmentalImpactIndicators - Reference: EMCK-D45-8.1
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 29.6718 m2; Volume: 0.244543 m3
Identity Data - Mark: 1
Mechanical - System Classification: Undefined,Sanitary,Power,Undefined
Mechanical - Flow - Drain Fixture Units: 0; Flow In: 0 m3/s; Flow Out: 0 m3/s; Refil Flow: 0 m3/s
Other - Drain Height: 459.92 mm; Drain Position Right: 157.77 mm; Drain Psition Center: 324.55 mm; Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact Duo_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact Duo_INT-EN: EMCK-D45-8.1; Front Clearance Safe: 500 mm; Left Clearance Safe: 500 mm; Right Clearance Safe: 500 mm; Top Clearance Safe: 500 mm; Type: EMCK-D45-8.1; Type Id: 43736
Phasing - Phase Created: New Construction
Visibility - Front Clearance: 500 mm; Left Clearance: 500 mm; Right Clearance: 500 mm; Right Side Connection: yes; Show Service Area: no; Top Clearance: 500 mm

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection | PredefinedType
Port_43794 | SOURCEANDSINK | CABLE | SystemType: ELECTRICAL
2 x Port_43794 | SOURCE | PIPE
Port_43794 | SINK | PIPE
Port_43794 | SOURCE | PIPE | SystemType: SEWAGE
